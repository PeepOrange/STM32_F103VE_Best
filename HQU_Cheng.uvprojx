# Keil uVision project HQU_Cheng.uvprojx, settings and files
target Best_Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HQU_Cheng
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD,
  c misc: --locale=english
  c include: .\Fatfs\option;.\Fatfs;.\STemWin522\Config;.\STemWin522\inc;.\STemWin522\Lib;.\STemWin522\OS;.\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;.\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\uCOS-III\uC-CPU;.\uCOS-III\uC-LIB;.\uCOS-III\uCOS-III\Source;.\User;.\User\app;.\User\bsp;.\User\os;.\Icon
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group APP
    ./User/: common.c
    ./User/app/: MyAPP.c
  group uC/Cfg
    ./User/os/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC/CPU
    ./uCOS-III/uC-CPU/: cpu_core.c
    ./uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ./uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/Source
    ./uCOS-III/uCOS-III/Source/: os.h os_type.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Port
    ./uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group BSP
    ./User/bsp/: beep.c bsp.c bsp_breathing.c bsp_calendar.c bsp_date.c bsp_esp8266.c bsp_i2c_ee.c bsp_i2c_gpio_ee.c bsp_ili9341_lcd.c bsp_led.c bsp_ov7725.c bsp_rtc.c bsp_sccb.c bsp_usart1.c bsp_usart2.c bsp_xpt2046_lcd.c fatfs_flash_spi.c key.c sim900a.c TouchPad.c
  group StemWin_V522
    ./STemWin522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ./STemWin522/Lib/: STemWin522_CM3_OS_Keil.lib
    ./STemWin522/OS/: GUI_X_uCOS.c GUI_X_Touch_Analog.c
  group Fatfs
    ./Fatfs/: diskio.c ff.c firecc936.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
